# Keil uVision project RTX_EX2.uvproj, settings and files
target RTX51 Tiny Ex2 (MCS-51)
  device: 80C32 NXP (founded by Philips)
  cpu: IRAM(0-0xFF)  CLOCK(33000000)
  output: RTX_EX2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: RTX_EX2.C ABSTRACT.TXT Conf_tny.A51
